$ CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT async_up_down in_bias in_inn out_adc
